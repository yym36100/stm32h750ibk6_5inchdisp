# Keil uVision project STM32H7_W25QXX.uvprojx, settings and files
target STM32H7_W25QXX (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32H750IBKx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00020000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: H750IBK6_16M
  AfterMake: cmd.exe /C copy "Objects\%L" ".\@L.FLM"
  c flags: Optim=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\SYSTEM\delay;.\SYSTEM\sys;.\SYSTEM\usart;.\HARDWARE\MPU;.\HARDWARE\QSPI;.\SYSTEM;.\HARDWARE\W25QXX;..\QSIP_W25QXX_Template-H7;..\W25Q128_QSPI_Keil烧写算法
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Documentation
    ./: Abstract.txt
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
  group Hardwere
    ./HARDWARE/QSPI/: qspi.c
    ./HARDWARE/W25QXX/: norflash.c
  group SYSTEM
    ./SYSTEM/sys/: sys.c
